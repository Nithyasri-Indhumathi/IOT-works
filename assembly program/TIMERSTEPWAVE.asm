CLR P0.7
LOOP:
CLR A
MOV TMOD ,#01H

MOV R0,#4
LOOP1:
MOV TH0,#0FFH
MOV TL0,#0F2H
MOV P1,A
ACALL DELAY
ADD A,#40
DJNZ R0,LOOP1
MOV R0,#4
LOOP2:
MOV TH0,#0FFH
MOV TL0,#0F2H
SUBB A,#40
MOV P1,A
ACALL DELAY
DJNZ R0,LOOP2
SJMP LOOP
DELAY:
SETB TR0
AGAIN:
JNB TF0,AGAIN
CLR TR0
CLR TF0
RET
END

