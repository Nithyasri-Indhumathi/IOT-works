ORG 0000H
LJMP MAIN

ORG 30H
MAIN:
MOV IE,#10010010B
MOV TMOD ,#22H
MOV SCON,#50H
MOV TH0,#0F0H
MOV TH1,#-6
SETB TR0
SETB TR1
MOV SBUF,#'A'

ORG 0023H
LJMP SER

ORG 50H
SER:
JB TI,L1
;MOV A,SBUF
;CLR RI
;RETI
L1:CLR TI
RETI

ORG 000BH
LJMP WAVE

ORG 60H
WAVE:
CLR P0.7
MOV A,P1
CPL A
MOV P1,A
RETI