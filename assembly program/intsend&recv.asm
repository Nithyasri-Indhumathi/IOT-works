ORG 0000H
LJMP MAIN
ORG 30H
MAIN:
MOV SCON,#50H
MOV TMOD,#20H
MOV TH1,#-6
MOV IE,#10010000B
MOV R0,#40H
SETB TR1
MOV A,@R0
MOV SBUF,A
ORG 0023H
LJMP GO
ORG 50H
GO:
JNB RI,TRANS
MOV A,SBUF
MOV @R0,A
INC R0
CLR RI
RETI
TRANS:
MOV SBUF,A
CLR TI
RETI
