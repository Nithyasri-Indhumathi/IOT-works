ORG 0000H
LJMP MAIN
ORG 30H
MAIN:
MOV SCON,#50H
MOV TMOD,#22H
MOV TH1,#-6
MOV TH0,#0F0H
MOV IE,#10000010B
SETB TR0
SETB TR1
MOV DPTR ,#STR
LOOP:
MOVC A,@A+DPTR
JZ HLT
MOV SBUF,A
L1:JNB TI,L1
CLR TI
CLR A
INC DPTR
SJMP LOOP
HLT:SJMP HLT
ORG 000BH
LJMP SQ
ORG 57H
SQ:
CLR P0.7
MOV A,P1
CPL A
MOV P1,A
RETI
ORG 65H
STR:
DB "HI HELLO"
