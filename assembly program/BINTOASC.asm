RAM_ADDR EQU 50H
ASCII EQU 60H
COUNT EQU 3
ACALL BIN_DECI
ACALL DECI_ASC
SJMP $
BIN_DECI:
MOV R0,#RAM_ADDR
MOV  A,@R0
MOV B,#0AH
DIV AB
MOV @R0,B
MOV B,#0AH
DIV AB
INC R0
MOV @R0,B
INC R0
MOV @R0,A
RET
DECI_ASC:
MOV R0,#RAM_ADDR
MOV R1,#ASCII
MOV R2,#COUNT
LOOP:
MOV A,@R0
ORL A,#30H
MOV @R1,A
INC R0
INC R1
DJNZ R2,LOOP
RET
END















