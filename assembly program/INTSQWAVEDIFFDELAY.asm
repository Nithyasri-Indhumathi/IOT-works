ORG 0000H
LJMP MAIN

ORG 30H
MAIN:

MOV IE,#10001000B
MOV TMOD ,#10H
MOV TH1,#0FCH
MOV TL1,#018H
SETB TR1
BACK:
MOV A,P3
MOV P2,A
SJMP BACK

ORG 001BH
LJMP INTER

ORG 60H
INTER:
CLR P0.7
CLR TR1
MOV P1,#00H
MOV R0,#0FH
L1:
DJNZ R0,L1
MOV TH1,#0FCH
MOV TL1,#018H
MOV P1,#55H
SETB TR1
RETI
