CLR P0.7
LOOP:
CLR A
MOV TMOD,#01H
MOV TH0,#0FFH
MOV TL0,#0CDH
MOV P1,A
ACALL DELAY
ADD A,#40
MOV R0,#3
LOOP1:
MOV TH0,#0FFH
MOV TL0,#0F2H
MOV P1,A
ACALL DELAY
ADD A,#40
DJNZ R0,LOOP1
MOV R2,A
MOV R1,#5
L1:
ADD A,#5
MOV P1,A
DJNZ R1,L1
MOV R1,#5
L2:
SUBB A,#5
MOV P1,A
DJNZ R1,L2
MOV A,R2
MOV R0,#3
LOOP2:
MOV TH0,#0FFH
MOV TL0,#0F2H
SUBB A,#40
MOV P1,A
ACALL DELAY
DJNZ R0,LOOP2
SJMP LOOP
DELAY:
SETB TR0
AGAIN:
JNB TF0 ,AGAIN
CLR TR0
CLR TF0
RET

END


