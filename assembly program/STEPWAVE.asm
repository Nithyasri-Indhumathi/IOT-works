CLR A
CLR P0.7
L1:
MOV R0,#3
OUTER:
CLR A
MOV P1,A
ACALL DELAY1
ADD A,#40
LOOP1:
MOV P1,A
ACALL DELAY
ADD A,#40
DJNZ R0,LOOP1
MOV R0,#3
MOV R1,A
MOV R2,#5
L2:
ADD A,#5
MOV P1,A
DJNZ R2,L2
MOV R2,#5
L3:
SUBB A,#5
MOV P1,A
DJNZ R2,L3
MOV A,R1
LOOP2:
SUBB A,#40
MOV P1,A
ACALL DELAY
DJNZ R0,LOOP2
SJMP L1
DELAY:
MOV R1,#20H
LOOP:DJNZ R1,LOOP
RET
DELAY1:
MOV R1,#30H
LO:DJNZ R1,LO
RET
END





